FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://config-5.15.147-sun55iw3"
DT_FILES_PATH += "${THISDIR}/device-tree:"